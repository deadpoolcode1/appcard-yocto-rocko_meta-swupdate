require swupdate.inc
require swupdate_tools.inc

SRCREV = "32f736f993388563511510359e84c71dae804ce2"
